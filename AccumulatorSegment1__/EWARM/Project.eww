<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\AccumulatorSegment1__.ewp</path>
  </project>
  <batchBuild />
</workspace>
